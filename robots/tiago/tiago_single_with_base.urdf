Commit message: fixed test_simple_tiago_JscAndGoto

File: robots/tiago/tiago_single_with_base.urdf (robot description, URDF)
Before this commit: robot tiago, 47 links, 46 joints
Joints:
- joint wheel_left_joint: type continuous -> prismatic
- joint wheel_right_joint: type continuous -> prismatic
